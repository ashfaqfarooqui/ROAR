Commit message: adding code to simulate lift

File: Task2/urdf/robot.urdf (robot description, URDF)
Before this commit: robot lift, 6 links, 6 joints
Joints:
- joint left_arm_to_lift: child lift -> left_arm; parent left_arm -> lift
